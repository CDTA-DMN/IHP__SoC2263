v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} -40 -40 0 0 {name=p1 lab=VDD}
C {iopin.sym} -40 -20 0 0 {name=p2 lab=VSS}
C {ipin.sym} -20 0 0 0 {name=p3 lab=I1U}
C {opin.sym} -30 20 0 0 {name=p4 lab=clk}
